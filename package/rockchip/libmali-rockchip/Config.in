## package/rockchip/libmali-rockchip/Config.in
```kconfig
config BR2_PACKAGE_LIBMALI_ROCKCHIP
	bool "libmali-rockchip"	
	help
	  LibMali userspace driver
```
